options:
  parameters:
    author: Franco Venturi
    generate_options: no_gui
    id: ysf_receiver
    output_language: python
    title: YSF Receiver
  states: {}

blocks:
- name: audio_samp_rate
  id: variable
  parameters:
    value: '8000'
  states: {}
- name: cutoff
  id: variable
  parameters:
    value: '24000'
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '41'
  states: {}
- name: fmdemod_quadri_K
  id: variable
  parameters:
    value: '0.340447550238101026565118445432744920253753662109375'
  states: {}
- name: freq_offset
  id: variable
  parameters:
    value: '25000'
  states: {}
- name: if_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: transition_bw
  id: variable
  parameters:
    value: '7200'
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '1e-2'
    decay_rate: '1e-4'
    gain: '1.0'
    max_gain: '1'
    reference: '1.0'
    type: float
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: fmdemod_quadri_K
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: audio_samp_rate
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '32768'
  states: {}
- name: digiham_dc_block_0
  id: digiham_dc_block
  parameters: {}
  states: {}
- name: digiham_digitalvoice_filter_0
  id: digiham_digitalvoice_filter
  parameters: {}
  states: {}
- name: digiham_gfsk_demodulator_0
  id: digiham_gfsk_demodulator
  parameters:
    samples_per_symbol: '10'
  states: {}
- name: digiham_mbe_synthesizer_0
  id: digiham_mbe_synthesizer
  parameters:
    mbe_bitrate: '0'
    mbe_cwds: ''
    mbe_index: '0'
    mbe_unvoiced_quality: '3'
    type: YSF
    ysf_mode: '0'
  states: {}
- name: digiham_rrc_filter_0
  id: digiham_rrc_filter
  parameters:
    coeffs: ''
    gain: '0.0'
    n_zeros: '0'
    type: Wide
  states: {}
- name: digiham_ysf_decoder_0
  id: digiham_ysf_decoder
  parameters: {}
  states: {}
- name: filter_fft_low_pass_filter_0
  id: filter_fft_low_pass_filter
  parameters:
    cutoff_freq: '4000'
    decim: '1'
    gain: '1'
    samp_rate: if_rate
    type: ccc
    width: '320'
    win: window.WIN_HAMMING
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: freq_offset
    decim: decimation
    samp_rate: samp_rate
    taps: firdes.complex_band_pass(1, samp_rate, -cutoff, cutoff, transition_bw)
    type: ccc
  states: {}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: samp_rate / decimation / if_rate
    type: complex
  states: {}
- name: sdrplay3_rspdx_0
  id: sdrplay3_rspdx
  parameters:
    AGC: 'False'
    agc_set_point: '-30'
    antenna: Antenna C
    bandwidth: 200e3
    biasT: 'False'
    center_freq: 444.9e6
    dab_notch_filter: 'False'
    dc_offset_mode: 'False'
    debug_mode: 'False'
    freq_corr: '0'
    hdr_mode: 'False'
    if_gRdB: '40'
    iq_balance_mode: 'False'
    output_type: fc32
    rf_gR: '0'
    rf_notch_filter: 'False'
    rsp_selector: ''
    sample_rate: samp_rate
    sample_sequence_gaps_check: 'False'
    show_gain_changes: 'False'
  states: {}

connections:
- [analog_agc2_xx_0, '0', audio_sink_0, '0']
- [analog_quadrature_demod_cf_0, '0', digiham_dc_block_0, '0']
- [blocks_short_to_float_0, '0', analog_agc2_xx_0, '0']
- [digiham_dc_block_0, '0', digiham_rrc_filter_0, '0']
- [digiham_digitalvoice_filter_0, '0', blocks_short_to_float_0, '0']
- [digiham_gfsk_demodulator_0, '0', digiham_ysf_decoder_0, '0']
- [digiham_mbe_synthesizer_0, '0', digiham_digitalvoice_filter_0, '0']
- [digiham_rrc_filter_0, '0', digiham_gfsk_demodulator_0, '0']
- [digiham_ysf_decoder_0, '0', digiham_mbe_synthesizer_0, '0']
- [filter_fft_low_pass_filter_0, '0', analog_quadrature_demod_cf_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', mmse_resampler_xx_0, '0']
- [mmse_resampler_xx_0, '0', filter_fft_low_pass_filter_0, '0']
- [sdrplay3_rspdx_0, '0', freq_xlating_fir_filter_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-34-g95ee7221
